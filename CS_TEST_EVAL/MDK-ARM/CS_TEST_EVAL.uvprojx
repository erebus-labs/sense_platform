# Keil uVision project CS_TEST_EVAL.uvprojx, settings and files
target CS_TEST_EVAL Configuration (ARM-ADS)
  device: STM32F207VCTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CS_TEST_EVAL Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F2xx_HAL_Driver\Inc;..\Middlewares\Third_Party\FatFs\src\drivers;..\Middlewares\Third_Party\FatFs\src;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F2xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_iwdg.c stm32f2xx_hal_rcc.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_adc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_spi.c stm32f2xx_hal_cortex.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_rtc.c stm32f2xx_hal_gpio.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c
  group Application/User
    ../Src/: stm32f2xx_it.c bsp_driver_sd.c i2c.c tim.c dma.c gpio.c rtc.c stm32f2xx_hal_msp.c sdio.c usb_otg.c iwdg.c main.c spi.c wwdg.c adc.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f207xx.s
