# IAR project CS_TEST3.ewp, settings and files
configuration CS_TEST3 Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VC ST STM32F207VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F207xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F2xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\Middlewares\Third_Party\FatFs\src; ..\..\Middlewares\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: CS_TEST3 Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Application
    ./: 
  group Application/User
    ../../Src/: adc.c gpio.c i2c.c main.c sdio.c stm32f2xx_it.c wwdg.c adc.c bsp_driver_sd.c gpio.c i2c.c main.c sdio.c stm32f2xx_it.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c stm32f2xx_it.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c spi.c stm32f2xx_it.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c spi.c stm32f2xx_it.c tim.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c spi.c stm32f2xx_it.c tim.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c spi.c stm32f2xx_it.c tim.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c spi.c stm32f2xx_it.c tim.c usb_otg.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c spi.c stm32f2xx_it.c tim.c usb_otg.c wwdg.c adc.c bsp_driver_sd.c dma.c gpio.c i2c.c main.c sdio.c spi.c stm32f2xx_it.c tim.c usb_otg.c wwdg.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f207xx.s startup_stm32f207xx.s
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/EWARM
    ./: 
  group Application/User
    ./: 
  group Drivers
    ./: 
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c system_stm32f2xx.c system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_sdmmc.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/STM32F2xx_HAL_Driver
    ./: 
  group Drivers/CMSIS
    ./: 
  group Drivers/STM32F2xx_HAL_Driver
    ./: 
  group Middlewares
    ./: 
  group Middlewares/FatFs
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c sd_diskio.c
    ../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/FatFs
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c diskio.c ff.c ff_gen_drv.c
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c sd_diskio.c sd_diskio.c
    ../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c ccsbcs.c syscall.c ccsbcs.c syscall.c
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/FatFs
    ./: 
  group Middlewares/FatFs
    ./: 
  group Application
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares
    ./: 
  group Middlewares/
    ./: 
